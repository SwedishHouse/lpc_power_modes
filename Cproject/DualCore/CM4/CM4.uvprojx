# Keil uVision project CM4.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: LPC4357:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.10.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OBC_CM4 +hex
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: CORE_M4 DEV_KIT_USART
  c include: ..\Drivers;..\..\DeveloperKitLPC4357\;..\IAP
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: cm4_main.c
  group Drivers
    ../Drivers/: samsat_queue.c samsat_uart.c message_types.h samsat_ipc_config.h samsat_queue.h samsat_uart.h
    ../../DeveloperKitLPC4357/: Developer_Kit_LPC4357_rev_C.c Developer_Kit_LPC4357_rev_C.h
  group IAP
    ../IAP/: iap_18xx_43xx.c
  group Images
    ./: boot_Image.c M0_Image.c
software components: CMSIS:CORE 5.5.0, CMSIS Driver:USART 2.17, Device:GPDMA 1.6, Device:SCU 1.2, Device:Startup 1.0.0
