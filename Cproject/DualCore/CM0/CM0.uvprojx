# Keil uVision project CM0.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: LPC4357:Cortex-M0 NXP
  pack: Keil.LPC4300_DFP.2.10.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: OBC_CM0 +hex
  AfterMake: fromelf --cadcombined --output="..\CM4\M0_Image.c" ".\Objects\CM0.axf"
  c flags: Optim=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: CORE_M0 DEV_KIT_I2C
  c include: ..\Drivers;..\..\DeveloperKitLPC4357
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: cm0_main.c
  group Drivers
    ../Drivers/: samsat_queue.c samsat_ipc_config.h samsat_queue.h message_types.h samsat_i2c.c samsat_i2c.h
    ../../DeveloperKitLPC4357/: Developer_Kit_LPC4357_rev_C.c LM75.c
software components: CMSIS:CORE 5.5.0, Device:SCU 1.2, Device:Startup 1.0.0
