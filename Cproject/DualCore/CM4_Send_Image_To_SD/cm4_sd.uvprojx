# Keil uVision project cm4_sd.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: LPC4357:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.10.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cm4_sd
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: cm4_sd_main.c
software components: CMSIS:CORE 5.6.0, CMSIS Driver:SPI:SSP 2.12, Device:GPDMA 1.6, Device:GPIO 1.1, Device:SCU 1.2, Device:Startup 1.0.0
